options:
  parameters:
    author: Leonardo Galli / Signal companion
    catch_exceptions: 'True'
    category: '[GRC Hier Blocks]'
    cmake_opt: ''
    comment: 'Minimal WBFM receive path for Chapter 9. Receive-only. Open in GNU Radio Companion, set center frequency to a local FM broadcast, then Run. Block ids must match what gnuradio/grc_parse.py expects for CI.'
    copyright: ''
    description: 'RTL-SDR -> LPF -> WBFM Receive -> Audio Sink'
    gen_cmake: 'On'
    gen_linking: dynamic
    generate_options: qt_gui
    hier_block_src_path: '.:'
    id: wbfm_rtl_receive
    max_nouts: '0'
    output_language: python
    placement: (0,0)
    qt_qss_theme: ''
    realtime_scheduling: ''
    run: 'True'
    run_command: '{python} -u {filename}'
    run_options: prompt
    sizing_mode: fixed
    thread_safe_setters: ''
    title: WBFM RTL Receive
    window_size: (1000,600)
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [8, 8]
    rotation: 0
    state: enabled

blocks:
- name: Options
  id: options
  parameters:
    author: Leonardo Galli / Signal companion
    catch_exceptions: 'True'
    category: '[GRC Hier Blocks]'
    cmake_opt: ''
    comment: ''
    copyright: ''
    description: 'RTL-SDR -> LPF -> WBFM Receive -> Audio Sink'
    gen_cmake: 'On'
    gen_linking: dynamic
    generate_options: qt_gui
    hier_block_src_path: '.:'
    id: wbfm_rtl_receive
    max_nouts: '0'
    output_language: python
    placement: (0,0)
    qt_qss_theme: ''
    realtime_scheduling: ''
    run: 'True'
    run_command: '{python} -u {filename}'
    run_options: prompt
    sizing_mode: fixed
    thread_safe_setters: ''
    title: WBFM RTL Receive
    window_size: (1000,600)
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [8, 8]
    rotation: 0
    state: enabled

- name: samp_rate
  id: variable
  parameters:
    comment: 'RF sample rate into the stick (Hz). 2.4e6 is a common RTL-SDR starting point.'
    value: '2.4e6'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [200, 12]
    rotation: 0
    state: enabled

- name: center_freq
  id: variable
  parameters:
    comment: 'Center frequency (Hz). Set to a strong local FM broadcast for your area.'
    value: '100.1e6'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [360, 12]
    rotation: 0
    state: enabled

- name: channel_rate
  id: variable
  parameters:
    comment: 'Quadrature rate after channel filter / into WBFM Receive. 2.4e6 / 10 = 240e3.'
    value: '240e3'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [520, 12]
    rotation: 0
    state: enabled

- name: audio_rate
  id: variable
  parameters:
    comment: 'Audio sink rate (Hz). Must match WBFM audio output after decimation.'
    value: '48e3'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [680, 12]
    rotation: 0
    state: enabled

- name: RTL-SDR Source
  id: rtlsdr_source
  parameters:
    affinity: ''
    alias: ''
    ant0: ''
    ant1: ''
    ant10: ''
    ant11: ''
    ant12: ''
    ant13: ''
    ant14: ''
    ant15: ''
    ant16: ''
    ant17: ''
    ant18: ''
    ant19: ''
    ant2: ''
    ant20: ''
    ant21: ''
    ant22: ''
    ant23: ''
    ant24: ''
    ant25: ''
    ant26: ''
    ant27: ''
    ant28: ''
    ant29: ''
    ant3: ''
    ant30: ''
    ant31: ''
    ant4: ''
    ant5: ''
    ant6: ''
    ant7: ''
    ant8: ''
    ant9: ''
    args: ''''''
    bb_gain0: '20'
    bb_gain1: '20'
    bb_gain10: '20'
    bb_gain11: '20'
    bb_gain12: '20'
    bb_gain13: '20'
    bb_gain14: '20'
    bb_gain15: '20'
    bb_gain16: '20'
    bb_gain17: '20'
    bb_gain18: '20'
    bb_gain19: '20'
    bb_gain2: '20'
    bb_gain20: '20'
    bb_gain21: '20'
    bb_gain22: '20'
    bb_gain23: '20'
    bb_gain24: '20'
    bb_gain25: '20'
    bb_gain26: '20'
    bb_gain27: '20'
    bb_gain28: '20'
    bb_gain29: '20'
    bb_gain3: '20'
    bb_gain30: '20'
    bb_gain31: '20'
    bb_gain4: '20'
    bb_gain5: '20'
    bb_gain6: '20'
    bb_gain7: '20'
    bb_gain8: '20'
    bb_gain9: '20'
    bw0: '0'
    bw1: '0'
    bw10: '0'
    bw11: '0'
    bw12: '0'
    bw13: '0'
    bw14: '0'
    bw15: '0'
    bw16: '0'
    bw17: '0'
    bw18: '0'
    bw19: '0'
    bw2: '0'
    bw20: '0'
    bw21: '0'
    bw22: '0'
    bw23: '0'
    bw24: '0'
    bw25: '0'
    bw26: '0'
    bw27: '0'
    bw28: '0'
    bw29: '0'
    bw3: '0'
    bw30: '0'
    bw31: '0'
    bw4: '0'
    bw5: '0'
    bw6: '0'
    bw7: '0'
    bw8: '0'
    bw9: '0'
    center_freq0: center_freq
    center_freq1: '100e6'
    center_freq10: '100e6'
    center_freq11: '100e6'
    center_freq12: '100e6'
    center_freq13: '100e6'
    center_freq14: '100e6'
    center_freq15: '100e6'
    center_freq16: '100e6'
    center_freq17: '100e6'
    center_freq18: '100e6'
    center_freq19: '100e6'
    center_freq2: '100e6'
    center_freq20: '100e6'
    center_freq21: '100e6'
    center_freq22: '100e6'
    center_freq23: '100e6'
    center_freq24: '100e6'
    center_freq25: '100e6'
    center_freq26: '100e6'
    center_freq27: '100e6'
    center_freq28: '100e6'
    center_freq29: '100e6'
    center_freq3: '100e6'
    center_freq30: '100e6'
    center_freq31: '100e6'
    center_freq4: '100e6'
    center_freq5: '100e6'
    center_freq6: '100e6'
    center_freq7: '100e6'
    center_freq8: '100e6'
    center_freq9: '100e6'
    clock_rate: '0.0'
    clock_source0: ''
    clock_source1: ''
    clock_source2: ''
    clock_source3: ''
    clock_source4: ''
    clock_source5: ''
    clock_source6: ''
    clock_source7: ''
    comment: 'Close SDR++ / GQRX / rtl_433 before running. Osmocom RTL-SDR Source is an equivalent id on some installs (osmosdr_source); keep this filename and retarget if your palette differs.'
    corr0: '0'
    corr1: '0'
    corr10: '0'
    corr11: '0'
    corr12: '0'
    corr13: '0'
    corr14: '0'
    corr15: '0'
    corr16: '0'
    corr17: '0'
    corr18: '0'
    corr19: '0'
    corr2: '0'
    corr20: '0'
    corr21: '0'
    corr22: '0'
    corr23: '0'
    corr24: '0'
    corr25: '0'
    corr26: '0'
    corr27: '0'
    corr28: '0'
    corr29: '0'
    corr3: '0'
    corr30: '0'
    corr31: '0'
    corr4: '0'
    corr5: '0'
    corr6: '0'
    corr7: '0'
    corr8: '0'
    corr9: '0'
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    dc_offset_mode10: '0'
    dc_offset_mode11: '0'
    dc_offset_mode12: '0'
    dc_offset_mode13: '0'
    dc_offset_mode14: '0'
    dc_offset_mode15: '0'
    dc_offset_mode16: '0'
    dc_offset_mode17: '0'
    dc_offset_mode18: '0'
    dc_offset_mode19: '0'
    dc_offset_mode2: '0'
    dc_offset_mode20: '0'
    dc_offset_mode21: '0'
    dc_offset_mode22: '0'
    dc_offset_mode23: '0'
    dc_offset_mode24: '0'
    dc_offset_mode25: '0'
    dc_offset_mode26: '0'
    dc_offset_mode27: '0'
    dc_offset_mode28: '0'
    dc_offset_mode29: '0'
    dc_offset_mode3: '0'
    dc_offset_mode30: '0'
    dc_offset_mode31: '0'
    dc_offset_mode4: '0'
    dc_offset_mode5: '0'
    dc_offset_mode6: '0'
    dc_offset_mode7: '0'
    dc_offset_mode8: '0'
    dc_offset_mode9: '0'
    freq0: center_freq
    freq1: '100e6'
    gain0: '20'
    gain1: '20'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    maxoutbuf: '0'
    minoutbuf: '0'
    nchan: '1'
    num_mboards: '1'
    sample_rate: samp_rate
    sync: sync
    time_source0: ''
    time_source1: ''
    type: fc32
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [40, 160]
    rotation: 0
    state: enabled

- name: Low Pass Filter
  id: low_pass_filter
  parameters:
    affinity: ''
    alias: ''
    beta: '6.76'
    comment: 'Channel filter. Cutoff near +/-100 kHz is a starting point for one FM broadcast channel; change for Exercise 1.'
    cutoff: '100e3'
    decim: 'int(samp_rate/channel_rate)'
    gain: '1'
    interp: '1'
    maxoutbuf: '0'
    minoutbuf: '0'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50e3'
    win: window.WIN_HAMMING
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [320, 160]
    rotation: 0
    state: enabled

- name: WBFM Receive
  id: analog_wfm_rcv
  parameters:
    affinity: ''
    alias: ''
    audio_decimation: 'int(channel_rate/audio_rate)'
    comment: 'Wideband FM demodulator. Quadrature rate must match channel_rate.'
    maxoutbuf: '0'
    minoutbuf: '0'
    quad_rate: channel_rate
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [560, 180]
    rotation: 0
    state: enabled

- name: Audio Sink
  id: audio_sink
  parameters:
    affinity: ''
    alias: ''
    comment: 'Host sound device. Set samp_rate to audio_rate.'
    device_name: ''
    num_inputs: '1'
    ok_to_block: 'True'
    samp_rate: audio_rate
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [800, 200]
    rotation: 0
    state: enabled

connections:
- [rtlsdr_source, '0', low_pass_filter, '0']
- [low_pass_filter, '0', analog_wfm_rcv, '0']
- [analog_wfm_rcv, '0', audio_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0
